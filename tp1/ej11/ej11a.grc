options:
  parameters:
    author: Maxbarr007
    generate_options: qt_gui
    id: ej11b
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: L
  id: variable
  parameters:
    value: '2'
  states: {}
- name: M
  id: variable
  parameters:
    value: '3'
  states: {}
- name: fs_eff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fsin
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: F:\gnuradio\tp1\audiocheck.net_sin_300Hz_-3dBFS_3s.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
