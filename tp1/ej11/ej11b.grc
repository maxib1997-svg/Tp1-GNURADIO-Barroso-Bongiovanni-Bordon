options:
  parameters:
    author: Maxbarr007
    generate_options: qt_gui
    id: ej11b
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: L
  id: variable
  parameters:
    value: '2'
  states: {}
- name: M
  id: variable
  parameters:
    value: '3'
  states: {}
- name: fs_eff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fsin
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: F:\gnuradio\tp1\audiocheck.net_sin_300Hz_-3dBFS_3s.wav
    repeat: 'True'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '3'
    taps: firdes.low_pass(1.0, 96000, 8000, 1000)
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '2'
    taps: firdes.low_pass(1.0, 48000, 8000, 1000)
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [blocks_throttle2_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [fir_filter_xxx_0, '0', audio_sink_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
